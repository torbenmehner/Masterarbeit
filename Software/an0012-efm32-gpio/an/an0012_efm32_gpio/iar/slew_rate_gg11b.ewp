# IAR project slew_rate_gg11b.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\common\drivers; ..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\platform\middleware\glib; ..\..\..\platform\emdrv\common\inc; ..\..\..\platform\emdrv\ustimer\config; ..\..\..\platform\emdrv\ustimer\inc; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG11B820F2048GL192
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: slew_rate_gg11b.bin
  ILINK.IlinkOutputFile: slew_rate_gg11b.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../hardware/kit/common/drivers/: display.c displayls013b7dh06.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
    ../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/emlib/src/: em_assert.c em_wdog.c em_rmu.c em_cmu.c em_emu.c em_gpio.c em_rtcc.c em_core.c em_ldma.c em_prs.c em_system.c em_usart.c em_timer.c em_letimer.c
  group Source
    ../src/: main_slew_rate.c
