<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gpio_conf_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_gg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_lg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_wg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_wg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_wg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_wg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_zg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_hg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_pg1b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_pg1b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_pg1b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_pg1b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\slew_rate_pg1b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_pg12b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_pg12b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_pg12b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_pg12b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\slew_rate_pg12b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_conf_gg11b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_periph_gg11b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_int_gg11b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_prs_gg11b.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\slew_rate_gg11b.ewp</path>
  </project>

  <batchBuild/>
</workspace>
