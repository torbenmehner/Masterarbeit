# IAR project gpio_prs_wg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\EFM32WG_STK3800\config; ..\..\..\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32WG990F256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpio_prs_wg.bin
  ILINK.IlinkOutputFile: gpio_prs_wg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../platform/emlib/src/: em_adc.c em_cmu.c em_gpio.c em_emu.c em_prs.c em_system.c
  group Source
    ../src/: main_gpio_prs.c
