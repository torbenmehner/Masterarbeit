# Keil uVision project slew_rate_gg11b.uvprojx, settings and files
target slew_rate_gg11b (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: slew_rate_gg11b
  AfterMake: fromelf.exe --bin --output obj\slew_rate_gg11b.bin obj\slew_rate_gg11b.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\common\bsp;..\..\..\hardware\kit\common\drivers;..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\platform\emdrv\rtcdrv\config;..\..\..\platform\middleware\glib;..\..\..\platform\emdrv\common\inc;..\..\..\platform\emdrv\ustimer\config;..\..\..\platform\emdrv\ustimer\inc;..\src
  asm define: EFM32GG11B820F2048GL192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../hardware/kit/common/drivers/: display.c displayls013b7dh06.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
    ../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/emlib/src/: em_assert.c em_wdog.c em_rmu.c em_cmu.c em_emu.c em_gpio.c em_rtcc.c em_core.c em_ldma.c em_prs.c em_system.c em_usart.c em_timer.c em_letimer.c
  group Source
    ../src/: main_slew_rate.c
