# Keil uVision project gpio_periph_tg.uvprojx, settings and files
target gpio_periph_tg (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: gpio_periph_tg
  AfterMake: fromelf.exe --bin --output obj\gpio_periph_tg.bin obj\gpio_periph_tg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32TG\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\EFM32TG_STK3300\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32TG840F32
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_gpio.c em_emu.c em_system.c
  group Source
    ../src/: main_gpio_periph.c
