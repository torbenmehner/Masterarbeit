# Keil uVision project gpio_periph_hg.uvprojx, settings and files
target gpio_periph_hg (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: gpio_periph_hg
  AfterMake: fromelf.exe --bin --output obj\gpio_periph_hg.bin obj\gpio_periph_hg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32HG322F64
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32HG\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32HG322F64
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_gpio.c em_emu.c em_system.c
  group Source
    ../src/: main_gpio_periph_m0.c
