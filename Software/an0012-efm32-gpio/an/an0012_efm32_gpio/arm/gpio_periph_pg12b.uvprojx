# Keil uVision project gpio_periph_pg12b.uvprojx, settings and files
target gpio_periph_pg12b (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: gpio_periph_pg12b
  AfterMake: fromelf.exe --bin --output obj\gpio_periph_pg12b.bin obj\gpio_periph_pg12b.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32PB12B\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32PG12B500F1024GL125
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32PB12B/Source/ARM/: startup_efm32pg12b.s
    ../../../platform/Device/SiliconLabs/EFM32PB12B/Source/: system_efm32pg12b.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_gpio.c em_emu.c em_system.c
  group Source
    ../src/: main_gpio_periph_s1.c
