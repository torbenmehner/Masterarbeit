# Keil uVision project gpio_periph_zg.uvprojx, settings and files
target gpio_periph_zg (ARM-ADS)
  device: EFM32ZG222F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: gpio_periph_zg
  AfterMake: fromelf.exe --bin --output obj\gpio_periph_zg.bin obj\gpio_periph_zg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32ZG222F32
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32ZG\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\EFM32ZG_STK3200\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32ZG222F32
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../platform/Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_gpio.c em_emu.c em_system.c
  group Source
    ../src/: main_gpio_periph_m0.c
