# Keil uVision project gpio_periph_gg.uvprojx, settings and files
target gpio_periph_gg (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: gpio_periph_gg
  AfterMake: fromelf.exe --bin --output obj\gpio_periph_gg.bin obj\gpio_periph_gg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\EFM32GG_STK3700\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32GG990F1024
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_gpio.c em_emu.c em_system.c
  group Source
    ../src/: main_gpio_periph.c
