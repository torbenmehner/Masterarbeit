# IAR project gpio_prs_tg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 SiliconLaboratories EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32TG\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\EFM32TG_STK3300\config; ..\..\..\hardware\kit\common\bsp
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG840F32
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpio_prs_tg.bin
  ILINK.IlinkOutputFile: gpio_prs_tg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../platform/emlib/src/: em_adc.c em_cmu.c em_gpio.c em_emu.c em_prs.c em_system.c
  group Source
    ../src/: main_gpio_prs.c
