# IAR project gpio_prs_lg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 SiliconLaboratories EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32LG\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\EFM32LG_STK3600\config; ..\..\..\hardware\kit\common\bsp
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32LG990F256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpio_prs_lg.bin
  ILINK.IlinkOutputFile: gpio_prs_lg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../platform/emlib/src/: em_adc.c em_cmu.c em_gpio.c em_emu.c em_prs.c em_system.c
  group Source
    ../src/: main_gpio_prs.c
