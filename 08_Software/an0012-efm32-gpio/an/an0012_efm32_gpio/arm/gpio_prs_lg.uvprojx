# Keil uVision project gpio_prs_lg.uvprojx, settings and files
target gpio_prs_lg (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: gpio_prs_lg
  AfterMake: fromelf.exe --bin --output obj\gpio_prs_lg.bin obj\gpio_prs_lg.axf
  c flags: Optim=1 oTime=1
  c define: EFM32LG990F256
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32LG\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\EFM32LG_STK3600\config;..\..\..\hardware\kit\common\bsp
  asm define: EFM32LG990F256
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../platform/emlib/src/: em_adc.c em_cmu.c em_gpio.c em_emu.c em_prs.c em_system.c
  group Source
    ../src/: main_gpio_prs.c
